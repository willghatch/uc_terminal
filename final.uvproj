# Keil uVision project final.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: lab6
  c flags: Optim=4 oTime=1
  c define: STM32F10X_HD
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Source Group 1
    ./: startup_stm32f10x_hd.s lcd.c main.c ascii.c usart2.c ps2_over_gpioc.c terminal.c code_to_ascii.c dac.c
